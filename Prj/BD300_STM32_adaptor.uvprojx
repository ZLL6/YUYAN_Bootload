# Keil uVision project BD300_STM32_adaptor.uvprojx, settings and files
target bd300_stm32_adaptor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F072CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BD300_STM32_adaptor +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ./bin/BD300_STM32_adaptor.bin  ./Objects/BD300_STM32_adaptor.axf
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\App\command;..\App\INC;..\App\SRC;..\CMSIS\source;..\CMSIS\include;..\Library\inc;..\Library\src;..\MDK_StartUp;..\Library
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ../App/SRC/: can.c flash.c Led.c main.c Uart.c WWDG.c
  group CMSIS
    ../App/SRC/: Timer.c
    ../CMSIS/source/: system_stm32f0xx.c
  group library
    ../Library/src/: stm32f0xx_can.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_it.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group MDK_StartUP
    ../MDK_StartUp/: startup_stm32f072.s
